DEPENDS_append_class-native = " ovmf-native"
