DEPENDS_append_class-native_x86 = " ovmf-native"
DEPENDS_append_class-native_x86-64 = " ovmf-native"
