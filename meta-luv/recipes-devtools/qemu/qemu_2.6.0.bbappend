DEPENDS_${PN}_append_class-native_x86 = " ovmf"
DEPENDS_${PN}_append_class-native_x86-64 = " ovmf"
