RDEPENDS_append_class-native_x86 = " ovmf"
RDEPENDS_append_class-native_x86-64 = " ovmf"
