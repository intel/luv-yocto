DEPENDS_append_class-native_x86 = " ovmf"
DEPENDS_append_class-native_x86-64 = " ovmf"
