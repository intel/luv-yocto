FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-luv-color-background.patch \
	file://0001-add-done-command.patch"

SPLASH_IMAGES = "file://luv-splash.png;outsuffix=default"
