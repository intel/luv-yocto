FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-OvmfPkg-Enable-FPDT-in-OVMF.patch"
