RDEPENDS_${PN}-cache += "gzip findutils"
