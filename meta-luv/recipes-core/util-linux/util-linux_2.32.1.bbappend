FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-util-linux-do-not-compile-lsns.patch \
	"
