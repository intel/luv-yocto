require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

FILESEXTRAPATHS_prepend :="../../../meta/recipes-kernel/linux-libc-headers:"

SRC_URI[md5sum] = "251a5deee0fa6daf3f356b1bbda9eab8"
SRC_URI[sha256sum] = "b67ecafd0a42b3383bf4d82f0850cbff92a7e72a215a6d02f42ddbafcf42a7d6"
