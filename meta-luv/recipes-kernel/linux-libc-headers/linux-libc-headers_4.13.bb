require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

FILESEXTRAPATHS_prepend :="../../../meta/recipes-kernel/linux-libc-headers:"

SRC_URI[md5sum] = "ab1a2abc6f37b752dd2595338bec4e78"
SRC_URI[sha256sum] = "2db3d6066c3ad93eb25b973a3d2951e022a7e975ee2fa7cbe5bddf84d9a49a2c"
