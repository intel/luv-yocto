require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

FILESEXTRAPATHS_prepend :="../../../meta/recipes-kernel/linux-libc-headers:"

SRC_URI[md5sum] = "d39dd4ba2d5861c54b90d49be19eaf31"
SRC_URI[sha256sum] = "ad0823183522e743972382df0aa08fb5ae3077f662b125f1e599b0b2aaa12438"
