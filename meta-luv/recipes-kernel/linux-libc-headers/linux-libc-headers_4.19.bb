require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

FILESEXTRAPATHS_prepend :="../../../meta/recipes-kernel/linux-libc-headers:"

SRC_URI[md5sum] = "740a90cf810c2105df8ee12e5d0bb900"
SRC_URI[sha256sum] = "0c68f5655528aed4f99dae71a5b259edc93239fa899e2df79c055275c21749a1"
