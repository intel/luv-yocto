require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

FILESEXTRAPATHS_prepend :="../../../meta/recipes-kernel/linux-libc-headers:"

SRC_URI[md5sum] = "bee5fe53ee1c3142b8f0c12c0d3348f9"
SRC_URI[sha256sum] = "19d8bcf49ef530cd4e364a45b4a22fa70714b70349c8100e7308488e26f1eaf1"
