require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

FILESEXTRAPATHS_prepend :="../../../meta/recipes-kernel/linux-libc-headers:"

SRC_URI[md5sum] = "5bb13a03274b66b56c85b26682e407d7"
SRC_URI[sha256sum] = "9faa1dd896eaea961dc6e886697c0b3301277102e5bc976b2758f9a62d3ccd13"
