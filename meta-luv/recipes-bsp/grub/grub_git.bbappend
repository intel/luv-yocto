GRUB_IMAGE_aarch64 = "grub-efi-bootaa64.efi"
