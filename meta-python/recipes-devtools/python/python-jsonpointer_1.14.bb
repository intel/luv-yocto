inherit setuptools
require python-jsonpointer.inc
